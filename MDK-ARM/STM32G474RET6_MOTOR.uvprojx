# Keil uVision project STM32G474RET6_MOTOR.uvprojx, settings and files
target STM32G474RET6_MOTOR (6070000::V6.7::.\ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807EFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G474RET6_MOTOR +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4
  c include: ../Core/Inc;../debug;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../bringup;../bringup/math_tables;../Drivers/adc;../cal;../config;../motor/deadband;../motor/ident;../motor/speed_ident;../motor;../drivers/foc;../Drivers/encoder;../Drivers/as5047;../Drivers/kth7823;../platform;../board;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: STM32G474RET6_MOTOR\STM32G474RET6_MOTOR.sct
  link misc: --keep=*(.obs_tab)
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c cordic.c dma.c fdcan.c i2c.c usart.c opamp.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group debug
    ../debug/: dbg_monitor.c
  group bringup
    ../bringup/: COMMUNICATION_FDCAN.c bsp_dwt.c app_axis_jeoc.c
    ../Drivers/as5047/: as5047_protocol.c as5047_async.c
    ../Drivers/kth7823/: kth7823_protocol.c kth7823_async.c
    ../Drivers/encoder/: encoder.c encoder_chip.c
    ../platform/: encoder_spi_bus.c encoder_spi_bus_fast_spi1.c encoder_spi_bus_generic_g4.c adc_sample_stm32g4.c pwm_port_stm32g4_reg.c adc_foc_port_stm32g4_reg.c time_port_cortex_dwt.c
    ../board/: board_encoder_m1.c board_encoder_spi3.c board_axis_ports.c
    ../motor/: foc_svpwm.c motor_open_sweep.c motor_foc_loop.c motor_pll.c motor_outer_loop.c motor_current_exp_hooks.c motor_current.c motor_bind.c angle_route.c telem_ops_default.c telem_lut_dump.c telem_ident_dump.c motor_startup.c motor_if.c
    ../Drivers/foc/: motor_trig.c motor_trig_lut.c
    ../bringup/math_tables/: math_tables_sincos.c
    ../debug/: app_uart_dma_debug.c telem_table.c
    ../motor/telemetry/: obs_reg.c obs_vars.c obs_cli.c obs_preset.c
    ../cal/: encoder_cal.c motor_phase_binding.c factory_nvm.c phase_detect.c
    ../motor/observer/: emf_veq.c emf_smo.c emf_pll.c obs_soft_switch.c hfi_sqwave.c hfi_spd_obs.c hfi_pub.c obs_angle.c obs_inj.c observer_composite.c
    ../motor/experiment/: exp_runner.c exp_signoff.c exp_act_basic.c exp_cfg.c exp_tables.c
    ../config/: exp_rev141_params.c hfi_pll_cfg.c obs_num.c bsp_axes.c bridge_cubemx.c irq_priority.c motor_cfg_m1.c
    ../config/experiments/: exp_rev141.c exp_calib_chain.c
    ../motor/factory/: factory_runner.c
    ../config/plant/: m1_n5065.c
    ../config/routes/: r_hfi_standstill.c r_id_cal_pass0_rs.c r_sensed_pos_mit.c r_sensorless_pos_mit.c r_if_100rpm.c r_speed_1000rpm.c r_obs_veq_1000rpm.c r_flux_id_1000rpm.c r_bode_id_fc1000.c
    ../motor/ff/: ff_noop.c
    ../motor/iref/: iref_zero_d.c
    ../motor/outer/: outer_ops.c
    ../motor/isr/: isr_state.c isr_entry.c isr_sample.c isr_startup.c isr_current.c isr_modulate.c isr_telem.c
    ../motor/ident/: ident_module.c rs_ident.c l_hfi_ident.c ident_flow.c
    ../motor/speed_ident/: speed_ident_module.c speed_ident_flow.c
    ../drivers/foc/: foc_pi.c
  group motor/deadband
    ../motor/deadband/: deadband.c deadband_service.c deadband_id_cal.c deadband_flow.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
